# Keil uVision project ece5721_peps.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ece5721_peps
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: PART_TM4C123GH6PM,TARGET_IS_TM4C123_RB1
  c include: ..\..\..\..\Tools\TivaWare\SW-TM4C\TivaWare_C_Series-2.1.4.178\
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group App
    ./App/: main.c bcm_state.c bcm_state.h
  group Drivers
    ./Drivers/: ble_uart.c can_driver.c pwm_servo.c gpio_leds.c ble_uart.h can_driver.h pwm_servo.h gpio_leds.h bluefruit.c bluefruit.h
    ../../../../Tools/TivaWare/SW-TM4C/TivaWare_C_Series-2.1.4.178/driverlib/rvmdk/: driverlib.lib
software components: CMSIS:CORE 6.2.0, Device:Startup 1.0.1
